SUMMARY = "Production rootfs for the example confidential VM"
include example-rootfs-prod.inc
inherit core-image
