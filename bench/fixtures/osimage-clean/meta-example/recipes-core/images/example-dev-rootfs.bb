SUMMARY = "Development rootfs — not deployed"
include example-rootfs-dev.inc
inherit core-image
